# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;.\Driver;.\User
  group User
    ./User/: main.c
  group Lib
    ./Lib/: UART.c UART_Isr.c GPIO.c Delay.c NVIC.c ADC.c ADC.h ADC_Isr.c STC8H_PWM.h STC8H_PWM.c STC8H_PWM_Isr.c
  group OS
    ./OS/: Conf_tny.A51
  group Driver
    ./Driver/: Ultrasonic.c Light.c Key.c Battery.c Buzzer.c Motors.c Motors.h Tracker.h Tracker.c
